ORG 0000
;Pallindrome

MOV DPTR, #0250H
MOV R0, #50H
MOV R2, #00H

LOOP: MOVC A,@A+DPTR
JZ NEXT
MOV @R0,A
INC R2
INC R0
INC DPTR
CLR A
SJMP LOOP

NEXT: MOV R1, #50H
MOV R0, #51H
MOV A,R2
MOV R3,A
DEC R3
MOV R5, #00H

LOOP2: MOV A, @R1
SUBB A,@R0
JC SKIP

MOV A,@R1
MOV R4,A
MOV A,@R0
MOV @R1,A
MOV A,R4
MOV @R0,A

SKIP: INC R1
INC R0
DJNZ R3,LOOP2

CJNE R5,#00H,NEXT

HERE: SJMP HERE

ORG 250H
DB "ABBA"
